v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
N 495 -215 635 -215 {
lab=D[0:1]}
C {devices/ipin.sym} 310 -390 0 0 {name=p5 lab=Da


}
C {devices/opin.sym} 350 -390 0 0 {name=p17 lab=D[0:1]}
C {devices/ipin.sym} 310 -360 0 0 {name=p8 lab=CLK


}
C {devices/ipin.sym} 310 -330 0 0 {name=p19 lab=nRes


}
C {sky130_stdcells/dfrtp_1.sym} 405 -195 0 0 {name=x1[0:1] VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 315 -215 0 0 {name=p18 sig_type=std_logic lab=CLK}
C {devices/lab_pin.sym} 315 -175 0 0 {name=p25 sig_type=std_logic lab=nRes}
C {devices/lab_pin.sym} 315 -195 0 0 {name=p26 sig_type=std_logic lab=Da,D[0]}
C {devices/lab_pin.sym} 632.5 -215 2 0 {name=p29 sig_type=std_logic lab=D[0:1]}
C {devices/iopin.sym} 310 -300 0 0 {name=p1 lab=VDD


}
C {devices/iopin.sym} 310 -270 0 0 {name=p2 lab=GND


}
