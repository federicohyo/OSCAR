v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
B 2 1560 -1560 2360 -1160 {flags=graph
y1=0
y2=2
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=0.002
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
node="vmem1
x20.vsin
x4.vsin"
color="12 8 7"
dataset=-1
unitx=1
logx=0
logy=0
}
T {Neuron biases} 80 -1520 0 0 0.4 0.4 {}
T {Excitatory syn} 1110 -1775 0 0 0.4 0.4 {}
T {Neuron driven by excitatory and inh synapse} 1850 -970 0 0 0.4 0.4 {}
T {Power up reset} 145 -1280 0 0 0.4 0.4 {}
T {some small delay
} 2580 -920 0 0 0.4 0.4 {}
T {Inhibitory syn} 435 -1780 0 0 0.4 0.4 {}
T {analog pulse extender} 825 -950 0 0 0.4 0.4 {}
T {analog pulse extender} 815 -760 0 0 0.4 0.4 {}
N 520 -1170 520 -1150 {
lab=0}
N 520 -1260 520 -1230 {
lab=VDD}
N 1790 -790 1850 -790 {
lab=nack_cel1}
N 230 -1380 230 -1360 {
lab=0}
N 230 -1470 230 -1440 {
lab=vrefn}
N 150 -1380 150 -1360 {
lab=0}
N 150 -1470 150 -1440 {
lab=vleakn}
N 430 -1460 430 -1430 {
lab=ifahwp}
N 350 -1460 350 -1430 {
lab=ifnmdap}
N 540 -1460 540 -1430 {
lab=ifdcp}
N 660 -1460 660 -1430 {
lab=ifahthrp}
N 780 -1460 780 -1430 {
lab=ifthrp}
N 900 -1460 900 -1430 {
lab=ifcascn}
N 1030 -1460 1030 -1430 {
lab=ifahtaun}
N 2150 -770 2230 -770 {
lab=syncur}
N 1145 -1615 1145 -1595 {
lab=0}
N 1145 -1705 1145 -1675 {
lab=vetaudpip}
N 1245 -1615 1245 -1595 {
lab=0}
N 1245 -1705 1245 -1675 {
lab=vethrdpin}
N 1350 -1625 1350 -1605 {
lab=0}
N 1350 -1715 1350 -1685 {
lab=vestddpin}
N 1610 -890 1630 -890 {
lab=vetaudpip}
N 1610 -850 1620 -850 {
lab=vethrdpin}
N 1020 -1695 1020 -1665 {
lab=vspke}
N 1270 -890 1310 -890 {
lab=#net1}
N 1280 -870 1310 -870 {
lab=low}
N 1280 -850 1310 -850 {
lab=low}
N 1280 -830 1310 -830 {
lab=low}
N 1270 -810 1310 -810 {
lab=hi}
N 2150 -790 2170 -790 {
lab=nspk_tmp1}
N 185 -1140 185 -1120 {
lab=0}
N 185 -1230 185 -1200 {
lab=nRes}
N 2600 -820 2690 -820 {
lab=spk1}
N 2150 -750 2220 -750 {
lab=vmem1}
N 1020 -1605 1020 -1595 {
lab=0}
N 1020 -1595 1150 -1595 {
lab=0}
N 1150 -1595 1250 -1595 {
lab=0}
N 1250 -1595 1350 -1595 {
lab=0}
N 1350 -1605 1350 -1595 {
lab=0}
N 1620 -705 1640 -705 {
lab=vistddpip}
N 1620 -665 1630 -665 {
lab=vithrdpip}
N 1280 -705 1320 -705 {
lab=hi}
N 1290 -685 1320 -685 {
lab=low}
N 1290 -665 1320 -665 {
lab=low}
N 1290 -645 1320 -645 {
lab=low}
N 1280 -625 1320 -625 {
lab=#net2}
N 470 -1620 470 -1600 {
lab=0}
N 470 -1710 470 -1680 {
lab=vitaudpin}
N 570 -1620 570 -1600 {
lab=0}
N 570 -1710 570 -1680 {
lab=vithrdpip}
N 675 -1630 675 -1610 {
lab=0}
N 675 -1720 675 -1690 {
lab=vistddpip}
N 345 -1700 345 -1670 {
lab=vspki}
N 345 -1610 345 -1600 {
lab=0}
N 345 -1600 475 -1600 {
lab=0}
N 475 -1600 575 -1600 {
lab=0}
N 575 -1600 675 -1600 {
lab=0}
N 675 -1610 675 -1600 {
lab=0}
N 1095 -875 1205 -875 {
lab=#net1}
N 1205 -890 1205 -875 {
lab=#net1}
N 1205 -890 1270 -890 {
lab=#net1}
N 1085 -685 1205 -685 {
lab=#net2}
N 1205 -685 1205 -630 {
lab=#net2}
N 1205 -630 1280 -630 {
lab=#net2}
N 1280 -630 1280 -625 {
lab=#net2}
N 615 -895 615 -865 {
lab=vepulseextp}
N 675 -590 675 -570 {
lab=0}
N 1610 -870 1740 -870 {
lab=syncur}
N 1740 -870 1740 -810 {
lab=syncur}
N 1740 -810 2340 -810 {
lab=syncur}
N 2340 -810 2340 -760 {
lab=syncur}
N 2220 -760 2340 -760 {
lab=syncur}
N 2220 -770 2220 -760 {
lab=syncur}
N 1620 -685 1735 -685 {
lab=0}
C {neuron_analog_fc.sym} 2000 -700 0 0 {name=x1}
C {devices/code_shown.sym} 787.3828125 -1249.6484375 0 0 {name=Xyce only_toplevel=false value="
.TRAN 0.01us 2ms 
.PARAM AVDD=1.8V
.PRINT TRAN format=raw file=neuron_analog_fb_tb_xyce.raw v(*) i(*)
.OPTION DEVICE GMIN=1.0e-14
.OPTION LINSOL TYPE=AztecOO PREC_TYPE=ifpack
.SAVE
"}
C {devices/code.sym} 110 -725 0 0 {name=stdcell_lib only_toplevel=true value="tcleval(
* Standard cell simulation files
.include $::SKYWATER_STDCELLS/sky130_fd_sc_hd.spice
)"}
C {sky130_fd_pr/corner.sym} 285 -720 0 0 {name=CORNER only_toplevel=true corner=tt}
C {devices/vsource.sym} 520 -1200 0 0 {name=V2 value=\{aVDD\}}
C {devices/lab_pin.sym} 520 -1260 0 0 {name=p35 sig_type=std_logic lab=VDD}
C {devices/vsource.sym} 230 -1410 0 0 {name=V8 value=0.4}
C {devices/lab_pin.sym} 230 -1470 0 0 {name=p45 sig_type=std_logic lab=vrefn}
C {devices/vsource.sym} 150 -1410 0 0 {name=V9 value=0.5}
C {devices/lab_pin.sym} 150 -1470 0 0 {name=p46 sig_type=std_logic lab=vleakn}
C {devices/vsource.sym} 430 -1400 0 0 {name=V16 value=1.8}
C {devices/lab_pin.sym} 430 -1460 0 0 {name=p33 sig_type=std_logic lab=ifahwp}
C {devices/vsource.sym} 350 -1400 0 0 {name=V18 value=0.0}
C {devices/lab_pin.sym} 350 -1460 0 0 {name=p40 sig_type=std_logic lab=ifnmdap}
C {devices/vsource.sym} 540 -1400 0 0 {name=V19 value=1.8}
C {devices/lab_pin.sym} 540 -1460 0 0 {name=p41 sig_type=std_logic lab=ifdcp}
C {devices/vsource.sym} 660 -1400 0 0 {name=V21 value=1.8}
C {devices/lab_pin.sym} 660 -1460 0 0 {name=p42 sig_type=std_logic lab=ifahthrp}
C {devices/vsource.sym} 780 -1400 0 0 {name=V22 value=1.8}
C {devices/lab_pin.sym} 780 -1460 0 0 {name=p43 sig_type=std_logic lab=ifthrp}
C {devices/vsource.sym} 900 -1400 0 0 {name=V23 value=0.0}
C {devices/lab_pin.sym} 900 -1460 0 0 {name=p44 sig_type=std_logic lab=ifcascn}
C {devices/vsource.sym} 1030 -1400 0 0 {name=V24 value=0.0}
C {devices/lab_pin.sym} 1030 -1460 0 0 {name=p47 sig_type=std_logic lab=ifahtaun}
C {devices/lab_pin.sym} 1850 -650 0 0 {name=p3 sig_type=std_logic lab=vleakn}
C {devices/lab_pin.sym} 1850 -630 0 0 {name=p4 sig_type=std_logic lab=vrefn}
C {devices/lab_pin.sym} 1850 -750 0 0 {name=p5 sig_type=std_logic lab=ifnmdap}
C {devices/lab_pin.sym} 1850 -770 0 0 {name=p6 sig_type=std_logic lab=ifahwp}
C {devices/lab_pin.sym} 1850 -710 0 0 {name=p7 sig_type=std_logic lab=ifdcp}
C {devices/lab_pin.sym} 1850 -730 0 0 {name=p8 sig_type=std_logic lab=ifahthrp}
C {devices/lab_pin.sym} 1850 -690 0 0 {name=p9 sig_type=std_logic lab=ifthrp}
C {devices/lab_pin.sym} 1850 -670 0 0 {name=p10 sig_type=std_logic lab=ifcascn}
C {devices/lab_pin.sym} 1850 -610 0 0 {name=p11 sig_type=std_logic lab=ifahtaun}
C {dpi_syn_exc_4bit_fc.sym} 1460 -840 0 0 {name=x4}
C {devices/vsource.sym} 1145 -1645 0 0 {name=V7 value=1.55}
C {devices/lab_pin.sym} 1145 -1705 0 0 {name=p16 sig_type=std_logic lab=vetaudpip}
C {devices/vsource.sym} 1245 -1645 0 0 {name=V13 value=1.05}
C {devices/lab_pin.sym} 1245 -1705 0 0 {name=p26 sig_type=std_logic lab=vethrdpin}
C {devices/vsource.sym} 1350 -1655 0 0 {name=V10 value=0.38}
C {devices/lab_pin.sym} 1350 -1715 0 0 {name=p39 sig_type=std_logic lab=vestddpin}
C {devices/lab_pin.sym} 1625 -890 2 0 {name=p13 sig_type=std_logic lab=vetaudpip}
C {devices/lab_pin.sym} 1615 -850 2 0 {name=p14 sig_type=std_logic lab=vethrdpin}
C {devices/lab_pin.sym} 1610 -830 2 0 {name=p15 sig_type=std_logic lab=vestddpin}
C {devices/vsource.sym} 1020 -1635 0 1 {name=V12 value="pulse(0 1.8 10ns 1ns 1ns 1ns 25us 100)"}
C {devices/lab_pin.sym} 1020 -1695 0 0 {name=p19 sig_type=std_logic lab=vspke}
C {devices/lab_pin.sym} 795 -875 0 0 {name=p17 sig_type=std_logic lab=vspke}
C {tie_hi.sym} 250 -970 0 0 {name=x5}
C {tie_low.sym} 250 -890 0 0 {name=x6}
C {devices/lab_pin.sym} 400 -990 2 0 {name=p18 sig_type=std_logic lab=hi}
C {devices/lab_pin.sym} 1275 -810 0 0 {name=p20 sig_type=std_logic lab=hi}
C {devices/lab_pin.sym} 400 -910 2 0 {name=p24 sig_type=std_logic lab=low}
C {devices/lab_pin.sym} 1280 -870 0 0 {name=p27 sig_type=std_logic lab=low}
C {devices/lab_pin.sym} 400 -970 2 0 {name=p1 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 400 -890 2 0 {name=p2 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 1610 -790 2 0 {name=p30 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 2150 -710 2 0 {name=p31 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 2170 -790 2 0 {name=p54 sig_type=std_logic lab=nspk_tmp1}
C {devices/lab_pin.sym} 2225 -770 2 0 {name=p12 sig_type=std_logic lab=syncur}
C {devices/lab_pin.sym} 185 -1230 0 0 {name=p83 sig_type=std_logic lab=nRes}
C {devices/vsource.sym} 185 -1170 0 0 {name=V11 value="pulse(1.8 0 1ns 1us 1us 1us 10ms 1)"}
C {c_element_rj.sym} 2010 -890 0 0 {name=x2}
C {devices/lab_pin.sym} 1860 -890 0 0 {name=p53 sig_type=std_logic lab=ack1}
C {devices/lab_pin.sym} 1860 -870 0 0 {name=p55 sig_type=std_logic lab=spk1}
C {devices/lab_pin.sym} 2160 -910 2 0 {name=p56 sig_type=std_logic lab=ack_cel1}
C {devices/lab_pin.sym} 1860 -910 0 0 {name=p85 sig_type=std_logic lab=nRes}
C {devices/lab_pin.sym} 2850 -820 2 0 {name=p86 sig_type=std_logic lab=ack1}
C {devices/lab_pin.sym} 2520 -820 0 0 {name=p87 sig_type=std_logic lab=nspk_tmp1}
C {sky130_stdcells/inv_1.sym} 2560 -820 0 0 {name=x15 VGND=0 VNB=0 VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/inv_1.sym} 2730 -820 0 0 {name=x16 VGND=0 VNB=0 VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/inv_1.sym} 2810 -820 0 0 {name=x18 VGND=0 VNB=0 VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 2650 -820 3 0 {name=p88 sig_type=std_logic lab=spk1}
C {devices/lab_pin.sym} 2160 -870 2 0 {name=p52 sig_type=std_logic lab=VDD}
C {sky130_stdcells/inv_1.sym} 2380 -910 0 0 {name=x19 VGND=0 VNB=0 VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 2340 -910 0 0 {name=p91 sig_type=std_logic lab=ack_cel1}
C {devices/lab_pin.sym} 2420 -910 2 0 {name=p92 sig_type=std_logic lab=nack_cel1}
C {devices/lab_pin.sym} 1790 -790 0 0 {name=p50 sig_type=std_logic lab=nack_cel1}
C {devices/lab_pin.sym} 2220 -750 2 0 {name=p94 sig_type=std_logic lab=vmem1}
C {devices/lab_pin.sym} 520 -1150 0 0 {name=p96 sig_type=std_logic lab=0}
C {devices/lab_pin.sym} 185 -1120 0 0 {name=p98 sig_type=std_logic lab=0}
C {devices/lab_pin.sym} 1020 -1605 0 0 {name=p99 sig_type=std_logic lab=0}
C {devices/lab_pin.sym} 150 -1360 0 0 {name=p100 sig_type=std_logic lab=0}
C {devices/lab_pin.sym} 230 -1360 0 0 {name=p101 sig_type=std_logic lab=0}
C {devices/lab_pin.sym} 350 -1370 0 0 {name=p102 sig_type=std_logic lab=0}
C {devices/lab_pin.sym} 430 -1370 0 0 {name=p103 sig_type=std_logic lab=0}
C {devices/lab_pin.sym} 540 -1370 0 0 {name=p104 sig_type=std_logic lab=0}
C {devices/lab_pin.sym} 660 -1370 0 0 {name=p105 sig_type=std_logic lab=0}
C {devices/lab_pin.sym} 780 -1370 0 0 {name=p106 sig_type=std_logic lab=0}
C {devices/lab_pin.sym} 900 -1370 0 0 {name=p107 sig_type=std_logic lab=0}
C {devices/lab_pin.sym} 1030 -1370 0 0 {name=p108 sig_type=std_logic lab=0}
C {devices/lab_pin.sym} 1620 -645 2 0 {name=p121 sig_type=std_logic lab=vitaudpin}
C {devices/lab_pin.sym} 1630 -665 2 0 {name=p122 sig_type=std_logic lab=vithrdpip}
C {devices/lab_pin.sym} 1640 -705 2 0 {name=p123 sig_type=std_logic lab=vistddpip}
C {devices/lab_pin.sym} 785 -685 0 0 {name=p124 sig_type=std_logic lab=vspki}
C {devices/lab_pin.sym} 1620 -605 2 0 {name=p143 sig_type=std_logic lab=VDD}
C {dpi_syn_inh_4bit_fc.sym} 1470 -655 0 0 {name=x20}
C {devices/vsource.sym} 470 -1650 0 0 {name=V6 value=0.5}
C {devices/vsource.sym} 570 -1650 0 0 {name=V14 value=1.0}
C {devices/vsource.sym} 675 -1660 0 0 {name=V15 value=1.6}
C {devices/vsource.sym} 345 -1640 0 1 {name=V17 value="pulse(0 1.8 15ns 1ns 1ns 1ns 500us 100)"}
C {devices/lab_pin.sym} 345 -1700 0 0 {name=p131 sig_type=std_logic lab=vspki}
C {devices/lab_pin.sym} 345 -1610 0 0 {name=p133 sig_type=std_logic lab=0}
C {devices/lab_pin.sym} 470 -1710 2 0 {name=p134 sig_type=std_logic lab=vitaudpin}
C {devices/lab_pin.sym} 570 -1710 2 0 {name=p135 sig_type=std_logic lab=vithrdpip}
C {devices/lab_pin.sym} 675 -1720 2 0 {name=p136 sig_type=std_logic lab=vistddpip}
C {devices/lab_pin.sym} 1610 -810 0 1 {name=p38 sig_type=std_logic lab=0}
C {devices/lab_pin.sym} 1620 -625 0 1 {name=p49 sig_type=std_logic lab=0}
C {devices/lab_pin.sym} 2150 -730 0 1 {name=p51 sig_type=std_logic lab=0}
C {devices/lab_pin.sym} 2160 -890 0 1 {name=p67 sig_type=std_logic lab=0}
C {devices/lab_pin.sym} 400 -870 0 1 {name=p36 sig_type=std_logic lab=0}
C {devices/lab_pin.sym} 400 -950 0 1 {name=p37 sig_type=std_logic lab=0}
C {spike_extender.sym} 945 -875 0 0 {name=x9}
C {devices/lab_pin.sym} 795 -895 0 0 {name=p138 sig_type=std_logic lab=vepulseextp
}
C {devices/lab_pin.sym} 1095 -855 2 0 {name=p137 sig_type=std_logic lab=VDD}
C {spike_extender.sym} 935 -685 0 0 {name=x17}
C {devices/lab_pin.sym} 785 -705 0 0 {name=p116 sig_type=std_logic lab=vipulseextp
}
C {devices/lab_pin.sym} 1085 -665 2 0 {name=p119 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 1085 -705 0 1 {name=p115 sig_type=std_logic lab=0}
C {devices/lab_pin.sym} 1095 -895 0 1 {name=p118 sig_type=std_logic lab=0}
C {devices/vsource.sym} 615 -835 0 0 {name=V25 value=0.65}
C {devices/lab_pin.sym} 615 -895 0 0 {name=p114 sig_type=std_logic lab=vepulseextp}
C {devices/vsource.sym} 675 -620 0 0 {name=V26 value=0.65}
C {devices/lab_pin.sym} 675 -650 0 0 {name=p117 sig_type=std_logic lab=vipulseextp}
C {devices/lab_pin.sym} 675 -570 0 0 {name=p120 sig_type=std_logic lab=0}
C {devices/lab_pin.sym} 615 -805 0 0 {name=p125 sig_type=std_logic lab=0}
C {devices/lab_pin.sym} 1280 -850 0 0 {name=p21 sig_type=std_logic lab=low}
C {devices/lab_pin.sym} 1280 -830 0 0 {name=p22 sig_type=std_logic lab=low}
C {devices/lab_pin.sym} 1280 -705 0 0 {name=p23 sig_type=std_logic lab=hi}
C {devices/lab_pin.sym} 1290 -685 0 0 {name=p25 sig_type=std_logic lab=low}
C {devices/lab_pin.sym} 1290 -665 0 0 {name=p28 sig_type=std_logic lab=low}
C {devices/lab_pin.sym} 1290 -645 0 0 {name=p29 sig_type=std_logic lab=low}
C {devices/lab_pin.sym} 1735 -685 0 1 {name=p32 sig_type=std_logic lab=0}
