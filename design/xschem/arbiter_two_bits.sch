v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {arbiter_cell_two_bits_fc.sym} 410 -150 0 0 {name=x1}
C {devices/ipin.sym} 150 -90 0 0 {name=p1 lab=req[0:1]}
C {devices/opin.sym} 150 -70 0 0 {name=p2 lab=ack[0:1]}
C {devices/ipin.sym} 490 -90 0 0 {name=p3 lab=ack_cpu}
C {devices/opin.sym} 490 -70 0 0 {name=p4 lab=req_cpu}
C {devices/lab_pin.sym} 560 -190 0 1 {name=p5 lab=ack[1]}
C {devices/lab_pin.sym} 560 -170 0 1 {name=p6 lab=ack[0]}
C {devices/lab_pin.sym} 260 -190 0 0 {name=p7 lab=ack_cpu}
C {devices/lab_pin.sym} 560 -150 0 1 {name=p8 lab=req_cpu}
C {devices/lab_pin.sym} 260 -170 0 0 {name=p9 lab=req[0]}
C {devices/lab_pin.sym} 260 -150 0 0 {name=p10 lab=req[1]}
C {devices/iopin.sym} 150 -40 0 0 {name=p11 lab=VDD}
C {devices/iopin.sym} 150 -20 0 0 {name=p12 lab=GND}
C {devices/lab_pin.sym} 560 -110 0 1 {name=p13 lab=GND}
C {devices/lab_pin.sym} 560 -130 0 1 {name=p14 lab=VDD}
